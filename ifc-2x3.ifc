Properties of the parts of a building model (IFC2X3)

# File
Description: Differenzdruckschalter, 100…1000 Pa, Inneneinstellung, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: H5309136, Differenzdruckschalter, 100…1000 Pa, Inneneinstellung
In: Raum
Description: Differenzdruckschalter zur Überwachung von Überdruck, Differenz- oder Unterdruck von Luft und unbrennbaren, nicht aggressiven Gasen. Einsetzbar als Abzug- oder Ventilatorüberwachung oder Strömungswächter zur Sicherung elektrischer Heizregister, als Filterüberwachung, Luftdruckmangelsicherung oder Grenzwertregler. Hinweis: Wenn der Differenzdruckschalter einmal eine Spannung > 24 V und einen Strom > 0,1 A geschaltet hat, ist die Goldschicht an den Kontakten weggebrannt. Danach kann der Differenzdruckschalter nur noch mit dieser oder einer höheren Leistung betrieben werden. Hinweis: Das Schlauchset JZ-06/1 gehört nicht zum Lieferumfang und muss separat bestellt werden. Lieferung mit angebautem Montagebügel JZ-10.; Classification: EC000243 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: H5309136; ModelLabel: JDL-115; GlobalTradeItemNumber: 4050528044501; ProductURL: https://alre.de/produkt_H5309136
Pset_Specification - NominalLength: 0.093 m; NominalWidth: 0.076 m; NominalDepth: 0.063 m; NetWeight: 0.217
Pset_ALRE_ETIM_Properties - Breite: 93; Höhe: 76; Tiefe: 63; Anschluss: Schlauchstutzen; Anzahl der Hilfskontakte als Wechsler: 1; Ausführung des elektrischen Anschlusses: Schraubanschluss; Explosionsgeschützt: no; Schutzart (IP): IP54; Anfangswert Messbereich Druck: 100; Elektronische Ausführung: no; Endwert Messbereich Druck: 1000; Geeignet als Wächter: yes; Mediumtemperatur: -15; Max. Arbeitsdruck: 300; ETIM-Klasse: EC000243; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-H5309136.pdf
